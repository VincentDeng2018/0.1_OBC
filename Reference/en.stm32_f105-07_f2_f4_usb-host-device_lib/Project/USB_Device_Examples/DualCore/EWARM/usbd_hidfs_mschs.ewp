# IAR project usbd_hidfs_mschs.ewp, settings and files
configuration STM322xG-EVAL_USBD-HS_FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_hidfs_mschs.srec
  ILINK.IlinkOutputFile: STM322xG-EVAL_USBD-HS_FS.out
  ILINK.IlinkIcfFile: stm32f207xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM324xG-EVAL_USBD-HS_FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_STM324xG_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  ILINK.IlinkOutputFile: STM324xG-EVAL_USBD-HS_FS.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
configuration STM324x9i-EVAL_USBD-HS_FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM324x9I_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL
  ILINK.IlinkOutputFile: STM324x9i-EVAL_USBD-HS_FS.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  group App
    ../src/: app.c stm32fxxx_it.c usb_bsp.c usbd_hid_desc.c usbd_msc_desc.c usbd_storage_msd.c usbd_usr.c
  group Doc
    ../: readme.txt
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM32F2xx
    ./: startup_stm32f2xx.s
    ../src/: system_stm32f2xx.c
  group STM32F2xx/STM322xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_ioe.c stm322xg_eval_lcd.c stm322xg_eval_sdio_sd.c
  group STM32F2xx/STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_usart.c
  group STM32F4xx
    ./: startup_stm32f40xx.s startup_stm32f429_439xx.s
    ../src/: system_stm32f4xx.c
  group STM32F4xx/STM324x9I_EVAL
    ../../../../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_fmc_sdram.c stm324x9i_eval_ioe16.c stm324x9i_eval_ioe8.c stm324x9i_eval_lcd.c stm324x9i_eval_sdio_sd.c
  group STM32F4xx/STM324xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c stm324xg_eval_sdio_sd.c
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group USB Device/Class/HID
    ../../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group USB Device/Class/MSC
    ../../../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB Device/Library
    ../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
