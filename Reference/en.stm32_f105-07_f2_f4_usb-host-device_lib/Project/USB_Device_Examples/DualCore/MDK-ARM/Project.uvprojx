# Keil uVision project Project.uvprojx, settings and files
target STM322xG-EVAL_USBD-HS_FS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F207IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL_USBD-HS_FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY,USE_USB_OTG_FS
  c misc: --C99
  c include: ../inc;../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Include;../../../../Libraries/STM32F2xx_StdPeriph_Driver/inc;../../../../Libraries/STM32_USB_OTG_Driver/inc;../../../../Libraries/STM32_USB_Device_Library/Core/inc;../../../../Libraries/STM32_USB_Device_Library/Class/hid/inc;../../../../Libraries/STM32_USB_Device_Library/Class/msc/inc;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM322xG_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USBDevice/Library
    ../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_ioreq.c usbd_core.c usbd_req.c
  group App
    ../src/: usbd_usr.c stm32fxxx_it.c app.c usbd_storage_msd.c usb_bsp.c usbd_hid_desc.c usbd_msc_desc.c
  group USBDrivers
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_core.c usb_dcd_int.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM32F2xx/STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_flash.c misc.c stm32f2xx_sdio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_usart.c stm32f2xx_exti.c stm32f2xx_rcc.c stm32f2xx_dma.c stm32f2xx_syscfg.c
  group USBDevice/Class/MSC
    ../../../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_scsi.c usbd_msc_core.c usbd_msc_bot.c usbd_msc_data.c
  group USBDevice/Class/HID
    ../../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group Doc
    ../: readme.txt
  group STM32F4xx/STM324x9I_EVAL
    ../../../../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm324x9i_eval_sdio_sd.c stm324x9i_eval_lcd.c stm324x9i_eval_ioe16.c stm324x9i_eval_fmc_sdram.c stm324x9i_eval.c stm324x9i_eval_ioe8.c
  group STM32F2xx
    ../src/: system_stm32f2xx.c
    ./: startup_stm32f2xx.s
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_gpio.c stm32f4xx_dma2d.c stm32f4xx_i2c.c stm32f4xx_fmc.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_fsmc.c misc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_ltdc.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group STM32F4xx/STM324xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_sdio_sd.c stm324xg_eval.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c
  group STM32F2xx/STM322xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_sdio_sd.c stm322xg_eval_lcd.c stm322xg_eval_ioe.c stm322xg_eval.c
  group STM32F4xx
    ./: startup_stm32f40xx.s startup_stm32f429_439xx.s
    ../src/: system_stm32f4xx.c
target STM324xG-EVAL_USBD-HS_FS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM324xG-EVAL_USBD-HS_FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY,USE_USB_OTG_FS
  c misc: --C99
  c include: ../inc;../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../Libraries/STM32_USB_OTG_Driver/inc;../../../../Libraries/STM32_USB_Device_Library/Core/inc;../../../../Libraries/STM32_USB_Device_Library/Class/hid/inc;../../../../Libraries/STM32_USB_Device_Library/Class/msc/inc;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM324x9i-EVAL_USBD-HS_FS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM324x9i-EVAL_USBD-HS_FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM324x9I_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY,USE_USB_OTG_FS
  c misc: --C99
  c include: ../inc;../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../Libraries/STM32_USB_OTG_Driver/inc;../../../../Libraries/STM32_USB_Device_Library/Core/inc;../../../../Libraries/STM32_USB_Device_Library/Class/hid/inc;../../../../Libraries/STM32_USB_Device_Library/Class/msc/inc;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM324x9I_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0
