# IAR project usbd_vcp_loopback.ewp, settings and files
configuration STM322xG-EVAL_USBD-HS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_msc.srec
  ILINK.IlinkOutputFile: STM322xG-EVAL_USBD-HS.out
  ILINK.IlinkIcfFile: stm32f207xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM322xG-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; USE_USB_OTG_FS
  ILINK.IlinkOutputFile: STM322xG-EVAL_USBD-FS.out
configuration STM3210C-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  OBJCOPY.OOCOutputFile: usbd_vcp.srec
  ILINK.IlinkOutputFile: STM3210C-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f107xc_flash.icf
configuration STM324xG-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_STM324xG_EVAL; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  ILINK.IlinkOutputFile: STM324xG-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
configuration STM324xG-EVAL_USBD-HS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_STM324xG_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM324xG-EVAL_USBD-HS.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
configuration STM324x9i-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM324x9I_EVAL; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL
  ILINK.IlinkOutputFile: STM324x9i-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
configuration STM324x9i-EVAL_USBD-HS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM324x9I_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM324x9i-EVAL_USBD-HS.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
configuration STM324x9i-EVAL_USBD-HS-IN-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM324x9I_EVAL; USE_USB_OTG_HS; USE_EMBEDDED_PHY
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM324x9i-EVAL_USBD-FS-IN-HS.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
configuration STM32446-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F446xx; USE_STM32446_EVAL; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc
  OBJCOPY.OOCOutputFile: usbd_vcp_loopback.srec
  ILINK.IlinkOutputFile: STM32446-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f446_flash.icf
configuration STM32446-EVAL_USBD-HS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F446xx; USE_STM32446_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM32446-EVAL_USBD-HS.out
  ILINK.IlinkIcfFile: stm32f446_flash.icf
configuration STM32469-EVAL_USBD_FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F469_479xx; USE_STM32469I_EVAL; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM32469-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
configuration STM32469-EVAL_USBD_HS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F469_479xx; USE_STM32469I_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM32469-EVAL_USBD-HS.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
configuration STM32469-EVAL_USBD_HS_IN_FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F469_479xx; USE_STM32469I_EVAL; USE_USB_OTG_HS; USE_EMBEDDED_PHY
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM32469-EVAL_USBD-FS-IN-HS.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  group App
    ../src/: app.c stm32fxxx_it.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group Doc
    ../: readme.txt
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM32F10x
    ./: startup_stm32f10x_cl.s
    ../src/: system_stm32f10x.c
  group STM32F10x/STM3210C_EVAL
    ../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_lcd.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group STM32F2xx
    ./: startup_stm32f2xx.s
    ../src/: system_stm32f2xx.c
  group STM32F2xx/STM322xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_lcd.c
  group STM32F2xx/STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_usart.c
  group STM32F4xx
    ./: startup_stm32f40xx.s startup_stm32f429_439xx.s startup_stm32f446xx.s startup_stm32f469_479xx.s
    ../src/: system_stm32f4xx.c
  group STM32F4xx/STM324x9I_EVAL
    ../../../../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_fmc_sdram.c stm324x9i_eval_ioe8.c stm324x9i_eval_lcd.c
  group STM32F4xx/STM324xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_lcd.c
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group USB Device/Class/CDC
    ../../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core_loopback.c
  group USB Device/Library
    ../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
