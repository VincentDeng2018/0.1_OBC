# Keil uVision project Stm32_CiA418.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Stm32_CiA418 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\KeilProject;..\APP;..\HSI;..\HSI\CAN;..\HSI\GPIO;..\MCAL\CoreSupport;..\MCAL\DeviceSupport;..\MCAL\STM32F10x_StdPeriph_Driver\inc;..\MCAL;..\Module;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\Keil;..\Module\CANOpenCiA418\CANOpenStack;..\Module\CANOpenCiA418\Portable;..\Module\CANOpenCiA418\ProfileOD;..\HSI\Timer;..\HSI\SPI;..\HSI\LCD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_cl.s
  group APP
    ../APP/: main.c TSK_PeriodicTask.c TSK_TaskCommonApi.c
  group HSI
    ../HSI/CAN/: CAN_Driver.c
    ../HSI/GPIO/: GPIO_Driver.c
    ../HSI/: stm32f10x_it.c
    ../HSI/Timer/: TIM_Driver.c
    ../HSI/SPI/: SPI_Driver.c
    ../HSI/LCD/: LCD_TaskHandler.c lcd.c
  group MCAL
    ../MCAL/: system_stm32f10x.c
    ../MCAL/CoreSupport/: core_cm3.c
    ../MCAL/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/Keil/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group CANOPEN
    ../Module/CANOpenCiA418/CANOpenStack/: CanOpenBasic.c CanOpenLifeguard.c CanOpenState.c CanOpenSDO.c CanOpenNmt.c
    ../Module/CANOpenCiA418/Portable/: CAN_HandlerRTOS.c
    ../Module/CANOpenCiA418/ProfileOD/: CiA418_Profile.c
