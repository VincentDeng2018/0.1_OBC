# IAR project OBC_OnV3.5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105RB ST STM32F105RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: APP; FreeRTOS; FreeRTOS\include; FreeRTOS\portable\IAR; HSI; HSI\ADC; HSI\CAN; HSI\GPIO; HSI\LCD; HSI\Timer; HSI\PWM; MCAL; MCAL\CoreSupport; MCAL\DeviceSupport; MCAL\STM32F10x_StdPeriph_Driver\inc; Module\CANOpenCiA418\CANOpenStack; Module\CANOpenCiA418\Portable; Module\CANOpenCiA418\ProfileOD
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: OBC_OnV3.5.srec
  ILINK.IlinkOutputFile: OBC_OnV3.5.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CiA419 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: APP; FreeRTOS; FreeRTOS\include; FreeRTOS\portable\IAR; HSI; HSI\ADC; HSI\CAN; HSI\GPIO; HSI\LCD; HSI\Timer; MCAL; MCAL\CoreSupport; MCAL\DeviceSupport; MCAL\STM32F10x_StdPeriph_Driver\inc; Module\CANOpenCiA418\CANOpenStack; Module\CANOpenCiA418\Portable; Module\CANOpenCiA418\ProfileOD
configuration CiA418 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: APP; FreeRTOS; FreeRTOS\include; FreeRTOS\portable\IAR; HSI; HSI\CAN; HSI\GPIO; HSI\LCD; HSI\Timer; MCAL; MCAL\CoreSupport; MCAL\DeviceSupport; MCAL\STM32F10x_StdPeriph_Driver\inc; Module\CANOpenCiA418\CANOpenStack; Module\CANOpenCiA418\Portable; Module\CANOpenCiA418\ProfileOD
  group APP
    APP/: main.c TSK_PeriodicTask.c TSK_TaskCommonApi.c TSK_TaskCommonApi.h Version.h
  group FreeRTOS
    FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/include
    FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/portable/Common
    FreeRTOS/portable/Common/: mpu_wrappers.c
  group FreeRTOS/portable/IAR
    FreeRTOS/portable/IAR/: FreeRTOSConfig.h port.c portasm.s portmacro.h
  group FreeRTOS/portable/MemMang
    FreeRTOS/portable/MemMang/: heap_2.c
  group HSI
    HSI/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h UserDefineIsr.c
  group HSI/ADC
    HSI/ADC/: ADC_Config.h ADC_Driver.c ADC_Globals.h
  group HSI/CAN
    HSI/CAN/: CAN_Config.h CAN_Driver.c CAN_Globals.h
  group HSI/GPIO
    HSI/GPIO/: GPIO_Config.h GPIO_Driver.c GPIO_Globals.h
  group HSI/LCD
    HSI/LCD/: lcd.c lcd.h LCD_TaskHandler.c
  group HSI/PWM
    HSI/PWM/: PWM_Config.h PWM_Driver.c PWM_Globals.h
  group HSI/Timer
    HSI/Timer/: TIM_Config.h TIM_Driver.c TIM_Globals.h
  group MCAL
    MCAL/: system_stm32f10x.c system_stm32f10x.h
  group MCAL/CoreSupport
    MCAL/CoreSupport/: core_cm3.c
  group MCAL/DeviceSupport
    MCAL/DeviceSupport/: startup_stm32f10x_cl.s stm32f10x.h
  group MCAL/STM32F10x_StdPeriph_Driver/inc
    MCAL/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group MCAL/STM32F10x_StdPeriph_Driver/src
    MCAL/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Module/CANOpenCiA418/CANOpenStack
    Module/CANOpenCiA418/CANOpenStack/: CanOpenBasic.c CanOpenBasic.h CanOpenLifeguard.c CanOpenNmt.c CanOpenOdTypes.h CanOpenSDO.c CanOpenState.c CanOpenState.h
  group Module/CANOpenCiA418/Portable
    Module/CANOpenCiA418/Portable/: CAN_HandlerRTOS.c CAN_Portable.h
  group Module/CANOpenCiA418/ProfileOD
    Module/CANOpenCiA418/ProfileOD/: CiA418_Profile.cpp
