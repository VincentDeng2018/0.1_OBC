<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\OBC_OnV3.5.ewp</path>
  </project>
  <batchBuild/>
</workspace>


