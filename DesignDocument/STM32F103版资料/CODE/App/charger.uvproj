# Keil uVision project charger.uvproj, settings and files
target Charger (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: charger +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_CHARGER
  c include: ..\CMSIS\inc;..\EVAL\inc;..\FatFs\inc;..\STM32F10x_StdPeriph_Driver\inc;..\STM32_USB-FS-Device_Driver\inc;..\User\inc
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/src/: hw_config.c main.c mass_mal.c stm32_it.c system_stm32f10x.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c display.c lcd.c spi.c ctrl.c db.c communication.c
  group CMSIS
    ../CMSIS/src/: system_stm32f10x.c
    ../CMSIS/src/arm/: startup_stm32f10x_hd.s
  group USB-FS-Device_Driver
    ../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Deiver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group EVAL
    ../EVAL/src/: stm3210x_eval.c stm3210x_eval_sdio_sd.c
  group FAT_FS
    ../FatFs/src/: diskio.c ff.c ff_gen_drv.c sd_diskio.c
    ../FatFs/src/option/: syscall.c unicode.c
